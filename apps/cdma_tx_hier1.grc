<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cdma_tx_hier1</value></param>
<param><key>title</key><value>cdma_tx_hier1</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>cdma</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>head</value></param>
<param><key>value</key><value>cdma.packet_header2(cp.bits_per_header,cp.length_tag_name,cp.num_tag_name, cp.header_mod.bits_per_symbol(),tcm_type_selector, "tcm_type")</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tcm_type_selector</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import cdma</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cp</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>cp.additional_redundant_symbols_per_frame[tcm_type_selector]</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cp.payload_mod[tcm_type_selector].points()+(16-len(cp.payload_mod[tcm_type_selector].points()))*(0,)</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>cp.training</value></param>
<param><key>tags</key><value>""</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>(1-cp.training_percent/100.0)**0.5</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>frame_out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>header_bits_1_0_0</value></param>
<param><key>stream_id</key><value>Redudant Bits</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_1_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cp.header_mod.points()</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>stream_id</key><value>Redudant Bits</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>cp.header_mod.points()</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>(cp.training_percent/100.0)**0.5</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>Header Bits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>Payload Bits</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>cp.chips_per_symbol</value></param>
<param><key>taps</key><value>cp.pulse_training</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>cp.chips_per_symbol</value></param>
<param><key>taps</key><value>cp.pulse_data</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>cp.additional_redundant_symbols_per_frame[tcm_type_selector]*(0,)</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((cp.additional_redundant_symbols_per_frame[tcm_type_selector],), (0,), cp.length_tag_name)</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ninputs</key><value>3</value></param>
<param><key>lengthtagname</key><value>cp.length_tag_name</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>payload_input</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>cp.additional_make_multiple_bytes_per_frame[tcm_type_selector]*(0,)</value></param>
<param><key>tags</key><value>""</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>lengths</key><value>cp.payload_bytes_per_frame, cp.additional_make_multiple_bytes_per_frame[tcm_type_selector]</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>cp.additional_make_multiple_bytes_per_frame[tcm_type_selector]+cp.payload_bytes_per_frame</value></param>
<param><key>len_tag_key</key><value>cp.length_tag_name</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0_0</value></param>
<param><key>check</key><value>False</value></param>
<param><key>lengthtagname</key><value>cp.length_tag_name</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>cp.bits_per_uncoded_symbol[tcm_type_selector]</value></param>
<param><key>len_tag_key</key><value>cp.length_tag_name</value></param>
</block>
<block>
<key>trellis_encoder_xx</key>
<param><key>id</key><value>trellis_encoder_xx_0</value></param>
<param><key>type</key><value>bb</value></param>
<param><key>fsm_args</key><value>cp.fsm[tcm_type_selector]</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>blockwise</key><value>True</value></param>
<param><key>blocklength</key><value>cp.trellis_coded_payload_symbols_per_frame[tcm_type_selector]</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>Payload Bits</value></param>
</block>
<block>
<key>digital_packet_headergenerator_bb</key>
<param><key>id</key><value>digital_packet_headergenerator_bb_0</value></param>
<param><key>header_formatter</key><value>head.formatter()</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>header_bits_1_0</value></param>
<param><key>stream_id</key><value>Header Bits</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1_0</value></param>
<param><key>k</key><value>cp.bits_per_coded_symbol[tcm_type_selector]</value></param>
<param><key>l</key><value>8</value></param>
<param><key>len_tag_key</key><value>cp.length_tag_name</value></param>
</block>
<connection><source_block_id>blocks_vector_source_x_0_1_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>header_bits_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_1_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_1_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_1</source_block_id><sink_block_id>blocks_tagged_stream_mux_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1_1_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>digital_crc32_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_encoder_xx_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1</source_block_id><sink_block_id>trellis_encoder_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1_0</source_block_id><sink_block_id>digital_packet_headergenerator_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_packet_headergenerator_bb_0</source_block_id><sink_block_id>header_bits_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
